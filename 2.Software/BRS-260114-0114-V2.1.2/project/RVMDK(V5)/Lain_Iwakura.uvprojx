# Keil uVision project Lain_Iwakura.uvprojx, settings and files
target Lain_Iwakura (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MOD_F427IIH
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User\APP\GO-M8010-6;..\..\User\APP\motor_control;..\..\User\APP\pid;..\..\User\APP\remote;..\..\User\BSP\bsp_can;..\..\User\BSP\bsp_clkconfig;..\..\User\BSP\bsp_debug_usart;..\..\User\BSP\bsp_general_tim;..\..\User\BSP\bsp_key;..\..\User\BSP\bsp_usart_dma
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../../User/: main.c main.h stm32f4xx_it.c stm32f4xx_it.h
  group APP
    ../../User/APP/GO-M8010-6/: GO_M8010_6.c GO_M8010_6.h ris_protocol.h crc_ccitt.h
    ../../User/APP/motor_control/: motor_control.c motor_control.h
    ../../User/APP/pid/: pid.c pid.h struct_typedef.h
    ../../User/APP/remote/: remote.c remote.h
  group BSP
    ../../User/BSP/bsp_clkconfig/: bsp_clkconfig.c bsp_clkconfig.h
    ../../User/BSP/bsp_debug_usart/: bsp_debug_usart.c bsp_debug_usart.h
    ../../User/BSP/bsp_general_tim/: bsp_general_tim.c bsp_general_tim.h
    ../../User/BSP/bsp_key/: bsp_key.c bsp_key.h
    ../../User/BSP/bsp_usart_dma/: bsp_usart_dma.c bsp_usart_dma.h
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STMF4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group README
    ../../Readme/: readme.txt
